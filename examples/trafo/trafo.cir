* trafo

L1 1 0 100m
L2 2 0 1
K1 L1 L2 0.99
RL 2 0 100
I1 1 0 -1
RI1 1 0 0.1

.op
